File: Hardware/blackbox.kicad_sch (KiCad schematic)
At the start: 2 parts, among them U5 W25Q80DVUXIE-TR

Commit message: nc
Parts:
- renumbered C2 to C19
