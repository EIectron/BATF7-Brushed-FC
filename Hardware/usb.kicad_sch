File: Hardware/usb.kicad_sch (KiCad schematic)
At the start: 6 parts, among them J1 1051330011

Commit message: nc
Parts:
- renumbered J1 to J4, R9 to R6, R10 to R7, R11 to R8, R12 to R9
